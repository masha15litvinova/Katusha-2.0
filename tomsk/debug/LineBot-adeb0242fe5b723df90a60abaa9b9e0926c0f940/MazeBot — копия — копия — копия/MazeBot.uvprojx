# Keil uVision project MazeBot.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MazeBot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, STM32F407xx, STM32F40_41xxx, HSE_VALUE=12000000
  c misc: --feedback=unused --cpp11
  c include: .\src\circular_buffer;.\src\cmsis;.\src\external;.\src\global_macros;.\src\librares;.\src\main;.\src\spl4\inc;.\src\spl4\src;.\src\spl4;.\src\support_pacage\arm;.\src\support_pacage\gcc\linker;.\src\support_pacage\gcc;.\src\support_pacage\inc;.\src\support_pacage;.\src\time_service;.\src\uart4;.\src;.\src\librares\vl53l0x;.\src\librares\vl53l0x\core\inc;.\src\librares\vl53l0x\core\src;.\src\librares\vl53l0x\platform\inc;.\src\librares\vl53l0x\platform\src;.\src\librares\vl53l0x\core;.\src\librares\vl53l0x\platform;.\src\librares\display\Inc;.\src\librares\display\Src;.\src\librares\display\ssd1351
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --feedback=unused
  group main
    ./src/librares/: pins.h pinsStr.h
    ./src/main/: uart_settings.h project_config.h main.cpp RTE_Device.h startup_stm32f407xx.s system_stm32f4xx.c
  group cmsis
    ./src/cmsis/: cmsis_armclang.h cmsis_armcc.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h tz_context.h
  group time_service
    ./src/time_service/: time_service.h time_service.cpp
  group external
    ./src/external/: retarget.cpp
  group global_macros
    ./src/global_macros/: global_macros.h qt_global_macros.h stm32f1xx_global_macros.h stm32f3xx_global_macros.h stm32f4xx_global_macros.h stm32lxx_global_macros.h
  group uart
    ./src/uart4/: i_serial_port.h uart_handle.cpp uart_handle.h uart_handle_mock.h
  group map_operations
    ./src/librares/: map_operations.cpp map_operations.h
  group spl
    ./src/spl4/inc/: misc.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_spi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_syscfg.h
    ./src/spl4/: stm32f4xx_conf.h
    ./src/spl4/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group сamera
    ./src/librares/: camera.h camera.cpp
  group gyro
    ./src/librares/: gyro.cpp gyro.h
  group motor
    ./src/librares/: motor.h motor.cpp
  group mlx90614
    ./src/librares/: mlx906014.h mlx906014.cpp
  group vl53l0x
    ./src/librares/vl53l0x/: vl53l0x.cpp vl53l0x.h
    ./src/librares/vl53l0x/platform/: vl53l0x_i2c_platform.h vl53l0x_platform.cpp vl53l0x_platform.h vl53l0x_platform_log.h vl53l0x_types.h
    ./src/librares/vl53l0x/core/src/: vl53l0x_api.c vl53l0x_api_strings.c vl53l0x_api_core.c vl53l0x_api_calibration.c vl53l0x_api_ranging.c
  group servo
    ./src/librares/: servo.cpp servo.h
  group i2c
    ./src/librares/: i2c.h i2c.cpp
  group base_movment
    ./src/librares/: base_movment.cpp base_movment.h
  group display
    ./src/librares/: display.cpp display.h
    ./src/librares/display/ssd1351/: OLED_GFX.h OLED_GFX.cpp OLED_Driver.h OLED_Driver.cpp ASCII_Font.h
  group i_task
    ./src/main/: i_task.h
  group main_func
    ./src/librares/: main_func.h main_func.cpp
  group softI2C
    ./src/librares/: softI2C.h softI2C.cpp
  group posSensors
    ./src/librares/: pos_sens.cpp pos_sens.h
  group posSensorReader
    ./src/librares/: posSensReader.h posSensReader.cpp
  group analog_input
    ./src/librares/: analog_input.cpp analog_input.h
